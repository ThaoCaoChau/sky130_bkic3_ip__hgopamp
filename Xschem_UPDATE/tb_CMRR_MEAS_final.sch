v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
L 4 -2850 2070 3720 2070 {}
L 4 3720 2070 3720 3600 {}
L 4 -3270 3600 3720 3600 {}
L 4 -3270 3600 -3260 2070 {}
L 4 -3260 2070 -2710 2070 {}
L 4 -3390 710 3600 710 {}
L 4 -3390 -940 -3390 730 {}
L 4 -3390 -940 3570 -930 {}
L 4 3570 -930 3570 720 {}
B 2 -1970 1580 -1170 1980 {flags=graph
y1=-128.38002

ypos1=0
ypos2=2


unity=1


divx=5
subdivx=8
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=1
logy=0
color=4
node="\\"OUT db20()\\""

hilight_wave=-1



divy=10
subdivy=4
x2=7.2759718
y2=-128.07784
x1=-0.90797437}
B 2 -2880 1580 -2080 1980 {flags=graph
y1=-125.06608

ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=-0.90797437

divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
node=ph(vop)
color=4
dataset=-1
unitx=1
logx=0
logy=0
x2=7.2759718
y2=-120.27928}
T {MEAS_Aop} -1180 2200 0 0 2 2 {}
T {MEAS_Acm} -1090 510 0 0 2 2 {}
N 330 -690 330 -630 {
lab=VDD}
N 630 -690 630 -630 {
lab=VDD}
N 630 -500 630 -490 {
lab=#net1}
N 330 -530 330 -490 {
lab=A}
N 330 -430 330 -200 {
lab=VON}
N 330 -140 330 10 {
lab=P1}
N 330 70 330 160 {
lab=0}
N 330 160 630 160 {
lab=0}
N 630 70 630 160 {
lab=0}
N 630 -140 630 10 {
lab=P2}
N 630 -430 630 -200 {
lab=VOP}
N 370 -170 590 -170 {
lab=VB3}
N 370 40 590 40 {
lab=VB4}
N 300 40 330 40 {
lab=0}
N 300 40 300 160 {
lab=0}
N 300 160 330 160 {
lab=0}
N 630 40 670 40 {
lab=0}
N 670 40 670 160 {
lab=0}
N 630 160 670 160 {
lab=0}
N 300 -170 330 -170 {
lab=0}
N 300 -170 300 40 {
lab=0}
N 630 -170 670 -170 {
lab=0}
N 670 -170 670 40 {
lab=0}
N -550 -250 -380 -250 {
lab=0}
N -640 -250 -590 -250 {
lab=INN}
N -340 -250 -300 -250 {
lab=INN}
N -550 -220 -550 -140 {
lab=P}
N -460 -140 -380 -140 {
lab=P}
N -380 -220 -380 -140 {
lab=P}
N -460 -140 -460 -100 {
lab=P}
N -560 -70 -500 -70 {
lab=VB4}
N -460 0 -460 160 {
lab=0}
N -80 160 300 160 {
lab=0}
N 370 -460 590 -460 {
lab=VB2}
N 370 -600 590 -600 {
lab=VB1}
N 630 -600 660 -600 {
lab=VDD}
N 660 -690 660 -600 {
lab=VDD}
N 630 -690 660 -690 {
lab=VDD}
N 300 -600 330 -600 {
lab=VDD}
N 300 -690 300 -600 {
lab=VDD}
N 330 -690 630 -690 {
lab=VDD}
N 630 -460 660 -460 {
lab=VDD}
N 660 -600 660 -460 {
lab=VDD}
N 300 -460 330 -460 {
lab=VDD}
N 300 -600 300 -460 {
lab=VDD}
N -550 -530 -550 -280 {
lab=A}
N -170 -530 330 -530 {
lab=A}
N -380 -500 -380 -280 {
lab=#net1}
N 0 -500 630 -500 {
lab=#net1}
N -2220 -60 -2220 -20 {
lab=VB4}
N -2220 40 -2220 130 {
lab=0}
N -1970 40 -1970 130 {
lab=0}
N -1970 10 -1940 10 {
lab=0}
N -1940 10 -1940 130 {
lab=0}
N -1970 130 -1940 130 {
lab=0}
N -2250 10 -2220 10 {
lab=0}
N -2250 10 -2250 130 {
lab=0}
N -2250 130 -2220 130 {
lab=0}
N -2160 10 -2010 10 {
lab=VB4}
N -2220 -60 -2160 -60 {
lab=VB4}
N -2160 -60 -2160 10 {
lab=VB4}
N -1970 -540 -1970 -480 {
lab=VDD}
N -1970 -540 -1740 -540 {
lab=VDD}
N -1740 -540 -1740 -480 {
lab=VDD}
N -1900 -450 -1780 -450 {
lab=VB}
N -1900 -450 -1900 -400 {
lab=VB}
N -1970 -400 -1900 -400 {
lab=VB}
N -1970 -400 -1970 -360 {
lab=VB}
N -2220 -540 -2220 -200 {
lab=VDD}
N -1990 -540 -1970 -540 {
lab=VDD}
N -1970 -270 -1970 -20 {
lab=VB2}
N -1900 -330 -1780 -330 {
lab=VB2}
N -1900 -330 -1900 -270 {
lab=VB2}
N -1970 -270 -1900 -270 {
lab=VB2}
N -1740 -420 -1740 -360 {
lab=D17}
N -1740 -330 -1720 -330 {
lab=VDD}
N -1720 -450 -1720 -330 {
lab=VDD}
N -1740 -540 -1720 -540 {
lab=VDD}
N -1740 -450 -1720 -450 {
lab=VDD}
N -1990 -330 -1970 -330 {
lab=VDD}
N -1990 -450 -1990 -330 {
lab=VDD}
N -1990 -450 -1970 -450 {
lab=VDD}
N -1740 -270 -1740 -240 {
lab=VB3}
N -1740 -60 -1740 -50 {
lab=D13}
N -1700 -210 -1650 -210 {
lab=VB3}
N -1650 -270 -1650 -210 {
lab=VB3}
N -1740 -270 -1650 -270 {
lab=VB3}
N -1740 40 -1740 130 {
lab=0}
N -1940 130 -1740 130 {
lab=0}
N -1760 -20 -1740 -20 {
lab=0}
N -1760 -20 -1760 40 {
lab=0}
N -1760 40 -1740 40 {
lab=0}
N -1700 -20 -1670 -20 {
lab=D13}
N -1670 -60 -1670 -20 {
lab=D13}
N -1740 -60 -1670 -60 {
lab=D13}
N -460 -70 -410 -70 {
lab=0}
N -410 -70 -410 0 {
lab=0}
N -460 0 -410 0 {
lab=0}
N -1760 -210 -1760 -20 {
lab=0}
N -1760 -210 -1740 -210 {
lab=0}
N 2690 -550 2720 -550 {
lab=VDD}
N 2360 -550 2390 -550 {
lab=VDD}
N 2580 -310 2800 -310 {
lab=VCM}
N 2840 -310 3000 -310 {
lab=0}
N 2520 -20 2550 -20 {
lab=0}
N 2840 -20 2860 -20 {
lab=0}
N 2540 -380 2540 -340 {
lab=VB1}
N 2690 -380 2840 -380 {
lab=VB1}
N 2840 -380 2840 -340 {
lab=VB1}
N 2390 -440 2390 -340 {
lab=#net2}
N 2390 -440 3000 -440 {
lab=#net2}
N 3000 -440 3000 -340 {
lab=#net2}
N 2390 -500 2390 -440 {
lab=#net2}
N 2690 -500 2690 -380 {
lab=VB1}
N 2390 -280 2390 -240 {
lab=#net3}
N 2390 -240 2540 -240 {
lab=#net3}
N 2540 -280 2540 -240 {
lab=#net3}
N 2840 -280 2840 -240 {
lab=#net4}
N 2840 -240 3000 -240 {
lab=#net4}
N 3000 -280 3000 -240 {
lab=#net4}
N 2540 -240 2540 -50 {
lab=#net3}
N 2840 -240 2840 -50 {
lab=#net4}
N 2580 -20 2810 -20 {
lab=VB4}
N 2540 10 2540 50 {
lab=0}
N 2540 50 2840 50 {
lab=0}
N 2840 10 2840 50 {
lab=0}
N 2470 -550 2470 -500 {
lab=#net2}
N 2390 -500 2470 -500 {
lab=#net2}
N 2600 -550 2600 -500 {
lab=VB1}
N 2600 -500 2690 -500 {
lab=VB1}
N 2430 -550 2470 -550 {
lab=#net2}
N 2600 -550 2650 -550 {
lab=VB1}
N 2390 -620 2390 -580 {
lab=VDD}
N 2690 -620 2690 -580 {
lab=VDD}
N 2310 -310 2350 -310 {
lab=VON}
N 3040 -310 3090 -310 {
lab=VOP}
N 2360 -620 2360 -550 {
lab=VDD}
N 2390 -620 2690 -620 {
lab=VDD}
N 2720 -620 2720 -550 {
lab=VDD}
N 2690 -620 2720 -620 {
lab=VDD}
N 2520 -20 2520 50 {
lab=0}
N 2520 50 2540 50 {
lab=0}
N 2860 -20 2860 50 {
lab=0}
N 2840 50 2860 50 {
lab=0}
N 300 -690 330 -690 {
lab=VDD}
N -550 -140 -460 -140 {
lab=P}
N 330 -570 330 -530 {
lab=A}
N 630 -570 630 -500 {
lab=#net1}
N -2220 -140 -2220 -60 {
lab=VB4}
N -2180 10 -2160 10 {
lab=VB4}
N -1930 -450 -1900 -450 {
lab=VB}
N -1970 -420 -1970 -400 {
lab=VB}
N -1930 -330 -1900 -330 {
lab=VB2}
N -1970 -300 -1970 -270 {
lab=VB2}
N -1720 -540 -1720 -450 {
lab=VDD}
N -2220 -540 -1990 -540 {
lab=VDD}
N -1990 -540 -1990 -450 {
lab=VDD}
N -1740 -300 -1740 -270 {
lab=VB3}
N -1740 10 -1740 40 {
lab=0}
N -1740 -180 -1740 -60 {
lab=D13}
N -460 -40 -460 0 {
lab=0}
N 2390 -310 2540 -310 {
lab=0}
N 2540 -380 2690 -380 {
lab=VB1}
N 2390 -520 2390 -500 {
lab=#net2}
N 2690 -520 2690 -500 {
lab=VB1}
N 2360 -620 2390 -620 {
lab=VDD}
N -2220 130 -1970 130 {
lab=0}
N 630 -310 740 -310 {
lab=VOP}
N 230 -300 330 -300 {
lab=VON}
N -550 -530 -450 -530 {
lab=A}
N -100 -500 0 -500 {
lab=#net1}
N -460 160 -360 160 {
lab=0}
N -370 160 -60 160 {
lab=0}
N -460 -530 -130 -530 {
lab=A}
N -380 -500 -90 -500 {
lab=#net1}
N -330 160 50 160 {
lab=0}
N -690 -570 -690 -400 {
lab=#net5}
N -690 -570 -200 -570 {
lab=#net5}
N -200 -570 -200 -390 {
lab=#net5}
N -790 -370 -730 -370 {
lab=INN}
N -790 -370 -790 -250 {
lab=INN}
N -790 -250 -640 -250 {
lab=INN}
N -160 -360 -110 -360 {
lab=INN}
N -110 -360 -110 -250 {
lab=INN}
N -300 -250 -110 -250 {
lab=INN}
N -390 -590 -390 -570 {
lab=#net5}
N -390 -690 -390 -650 {
lab=VDD}
N -390 -690 300 -690 {
lab=VDD}
N -350 -620 -250 -620 {
lab=VB}
N -690 -340 -690 -20 {
lab=P1}
N -690 -20 330 -20 {
lab=P1}
N -200 -330 -200 -160 {
lab=P2}
N -200 -160 -200 -120 {
lab=P2}
N -200 -120 630 -120 {
lab=P2}
N -430 -620 -390 -620 {
lab=VDD}
N -430 -690 -430 -620 {
lab=VDD}
N -430 -690 -390 -690 {
lab=VDD}
N -690 -370 -630 -370 {
lab=VDD}
N -260 -360 -200 -360 {
lab=VDD}
N 670 160 780 160 {
lab=0}
N 660 -690 740 -690 {
lab=VDD}
N 960 -410 1000 -410 {
lab=VB}
N 1040 -680 1040 -440 {
lab=VDD}
N 1020 -680 1040 -680 {
lab=VDD}
N 1040 -450 1040 -410 {
lab=VDD}
N 1040 -380 1040 -330 {
lab=VX}
N 1040 -270 1040 170 {
lab=0}
N 1040 -360 1330 -360 {
lab=VX}
N 970 -200 1170 -200 {
lab=VOP}
N 1210 -170 1210 -80 {
lab=VY}
N 1210 -20 1210 170 {
lab=0}
N 1040 170 1210 170 {
lab=0}
N 1110 -50 1170 -50 {
lab=VB4}
N 1210 -50 1210 -20 {
lab=0}
N 1210 -200 1240 -200 {
lab=0}
N 1240 -200 1240 170 {
lab=0}
N 1210 170 1240 170 {
lab=0}
N 1040 -680 1220 -680 {
lab=VDD}
N 1220 -680 1360 -680 {
lab=VDD}
N 1210 -680 1210 -230 {
lab=VDD}
N 1210 -130 1330 -130 {
lab=VY}
N 1370 -330 1370 -160 {
lab=OUT}
N 1370 -100 1370 170 {
lab=0}
N 1240 170 1370 170 {
lab=0}
N 1370 -680 1370 -390 {
lab=VDD}
N 1360 -680 1370 -680 {
lab=VDD}
N 1370 -260 1510 -260 {
lab=OUT}
N 1370 -130 1390 -130 {
lab=0}
N 1390 -130 1390 -90 {
lab=0}
N 1370 -90 1390 -90 {
lab=0}
N 1370 -360 1400 -360 {
lab=VDD}
N 1400 -420 1400 -360 {
lab=VDD}
N 1370 -420 1400 -420 {
lab=VDD}
N 1040 -300 1060 -300 {
lab=VDD}
N 1060 -470 1060 -300 {
lab=VDD}
N 1040 -470 1060 -470 {
lab=VDD}
N 1510 -260 1630 -260 {
lab=OUT}
N 1370 170 1510 170 {
lab=0}
N 1510 170 1630 170 {
lab=0}
N 740 -310 930 -310 {
lab=VOP}
N 930 -310 930 -300 {
lab=VOP}
N 930 -300 1000 -300 {
lab=VOP}
N 930 -300 930 -200 {
lab=VOP}
N 930 -200 980 -200 {
lab=VOP}
N 790 160 1040 160 {
lab=0}
N 750 160 810 160 {
lab=0}
N 720 -690 1020 -680 {
lab=VDD}
N 1630 -240 1630 -200 {
lab=OUT}
N 1750 -240 1750 -200 {
lab=OUT}
N 1630 -140 1630 140 {
lab=0}
N 1750 -140 1750 140 {
lab=0}
N 1750 -260 1750 -240 {
lab=OUT}
N 1630 -260 1630 -240 {
lab=OUT}
N 1630 -260 1750 -260 {
lab=OUT}
N 1630 130 1630 170 {
lab=0}
N 1750 140 1750 170 {
lab=0}
N 1630 170 1750 170 {
lab=0}
N -2845 -760 -2845 -700 {
lab=VDD}
N -2975 -600 -2845 -600 {
lab=0}
N -2845 -640 -2845 -600 {
lab=0}
N -2775 -760 -2775 -700 {
lab=VCM}
N -2775 -640 -2775 -600 {
lab=0}
N -2775 -600 -2590 -600 {
lab=0}
N -2590 -750 -2590 -700 {
lab=INN}
N -2590 -640 -2590 -600 {
lab=0}
N -2845 -600 -2775 -600 {
lab=0}
N -620 -330 -620 -250 {
lab=INN}
N -620 -330 -310 -330 {
lab=INN}
N -310 -330 -310 -250 {
lab=INN}
N 570 2250 570 2310 {
lab=VDD}
N 870 2250 870 2310 {
lab=VDD}
N 870 2440 870 2450 {
lab=#net1}
N 570 2410 570 2450 {
lab=A}
N 570 2510 570 2740 {
lab=VON}
N 570 2800 570 2950 {
lab=P1}
N 570 3010 570 3100 {
lab=0}
N 570 3100 870 3100 {
lab=0}
N 870 3010 870 3100 {
lab=0}
N 870 2800 870 2950 {
lab=P2}
N 870 2510 870 2740 {
lab=VOP}
N 610 2770 830 2770 {
lab=VB3}
N 610 2980 830 2980 {
lab=VB4}
N 540 2980 570 2980 {
lab=0}
N 540 2980 540 3100 {
lab=0}
N 540 3100 570 3100 {
lab=0}
N 870 2980 910 2980 {
lab=0}
N 910 2980 910 3100 {
lab=0}
N 870 3100 910 3100 {
lab=0}
N 540 2770 570 2770 {
lab=0}
N 540 2770 540 2980 {
lab=0}
N 870 2770 910 2770 {
lab=0}
N 910 2770 910 2980 {
lab=0}
N -310 2690 -140 2690 {
lab=0}
N -400 2690 -350 2690 {
lab=INN}
N -100 2690 -60 2690 {
lab=INN}
N -310 2720 -310 2800 {
lab=P}
N -220 2800 -140 2800 {
lab=P}
N -140 2720 -140 2800 {
lab=P}
N -220 2800 -220 2840 {
lab=P}
N -320 2870 -260 2870 {
lab=VB4}
N -220 2940 -220 3100 {
lab=0}
N 160 3100 540 3100 {
lab=0}
N 610 2480 830 2480 {
lab=VB2}
N 610 2340 830 2340 {
lab=VB1}
N 870 2340 900 2340 {
lab=VDD}
N 900 2250 900 2340 {
lab=VDD}
N 870 2250 900 2250 {
lab=VDD}
N 540 2340 570 2340 {
lab=VDD}
N 540 2250 540 2340 {
lab=VDD}
N 570 2250 870 2250 {
lab=VDD}
N 870 2480 900 2480 {
lab=VDD}
N 900 2340 900 2480 {
lab=VDD}
N 540 2480 570 2480 {
lab=VDD}
N 540 2340 540 2480 {
lab=VDD}
N -310 2410 -310 2660 {
lab=A}
N 70 2410 570 2410 {
lab=A}
N -140 2440 -140 2660 {
lab=#net1}
N 240 2440 870 2440 {
lab=#net1}
N -1980 2880 -1980 2920 {
lab=VB4}
N -1980 2980 -1980 3070 {
lab=0}
N -1730 2980 -1730 3070 {
lab=0}
N -1730 2950 -1700 2950 {
lab=0}
N -1700 2950 -1700 3070 {
lab=0}
N -1730 3070 -1700 3070 {
lab=0}
N -2010 2950 -1980 2950 {
lab=0}
N -2010 2950 -2010 3070 {
lab=0}
N -2010 3070 -1980 3070 {
lab=0}
N -1920 2950 -1770 2950 {
lab=VB4}
N -1980 2880 -1920 2880 {
lab=VB4}
N -1920 2880 -1920 2950 {
lab=VB4}
N -1730 2400 -1730 2460 {
lab=VDD}
N -1730 2400 -1500 2400 {
lab=VDD}
N -1500 2400 -1500 2460 {
lab=VDD}
N -1660 2490 -1540 2490 {
lab=VB}
N -1660 2490 -1660 2540 {
lab=VB}
N -1730 2540 -1660 2540 {
lab=VB}
N -1730 2540 -1730 2580 {
lab=VB}
N -1980 2400 -1980 2740 {
lab=VDD}
N -1750 2400 -1730 2400 {
lab=VDD}
N -1730 2670 -1730 2920 {
lab=VB2}
N -1660 2610 -1540 2610 {
lab=VB2}
N -1660 2610 -1660 2670 {
lab=VB2}
N -1730 2670 -1660 2670 {
lab=VB2}
N -1500 2520 -1500 2580 {
lab=D17}
N -1500 2610 -1480 2610 {
lab=VDD}
N -1480 2490 -1480 2610 {
lab=VDD}
N -1500 2400 -1480 2400 {
lab=VDD}
N -1500 2490 -1480 2490 {
lab=VDD}
N -1750 2610 -1730 2610 {
lab=VDD}
N -1750 2490 -1750 2610 {
lab=VDD}
N -1750 2490 -1730 2490 {
lab=VDD}
N -1500 2670 -1500 2700 {
lab=VB3}
N -1500 2880 -1500 2890 {
lab=D13}
N -1460 2730 -1410 2730 {
lab=VB3}
N -1410 2670 -1410 2730 {
lab=VB3}
N -1500 2670 -1410 2670 {
lab=VB3}
N -1500 2980 -1500 3070 {
lab=0}
N -1700 3070 -1500 3070 {
lab=0}
N -1520 2920 -1500 2920 {
lab=0}
N -1520 2920 -1520 2980 {
lab=0}
N -1520 2980 -1500 2980 {
lab=0}
N -1460 2920 -1430 2920 {
lab=D13}
N -1430 2880 -1430 2920 {
lab=D13}
N -1500 2880 -1430 2880 {
lab=D13}
N -220 2870 -170 2870 {
lab=0}
N -170 2870 -170 2940 {
lab=0}
N -220 2940 -170 2940 {
lab=0}
N -1520 2730 -1520 2920 {
lab=0}
N -1520 2730 -1500 2730 {
lab=0}
N 2930 2390 2960 2390 {
lab=VDD}
N 2600 2390 2630 2390 {
lab=VDD}
N 2820 2630 3040 2630 {
lab=VCM}
N 3080 2630 3240 2630 {
lab=0}
N 2760 2920 2790 2920 {
lab=0}
N 3080 2920 3100 2920 {
lab=0}
N 2780 2560 2780 2600 {
lab=VB1}
N 2930 2560 3080 2560 {
lab=VB1}
N 3080 2560 3080 2600 {
lab=VB1}
N 2630 2500 2630 2600 {
lab=#net2}
N 2630 2500 3240 2500 {
lab=#net2}
N 3240 2500 3240 2600 {
lab=#net2}
N 2630 2440 2630 2500 {
lab=#net2}
N 2930 2440 2930 2560 {
lab=VB1}
N 2630 2660 2630 2700 {
lab=#net3}
N 2630 2700 2780 2700 {
lab=#net3}
N 2780 2660 2780 2700 {
lab=#net3}
N 3080 2660 3080 2700 {
lab=#net4}
N 3080 2700 3240 2700 {
lab=#net4}
N 3240 2660 3240 2700 {
lab=#net4}
N 2780 2700 2780 2890 {
lab=#net3}
N 3080 2700 3080 2890 {
lab=#net4}
N 2820 2920 3050 2920 {
lab=VB4}
N 2780 2950 2780 2990 {
lab=0}
N 2780 2990 3080 2990 {
lab=0}
N 3080 2950 3080 2990 {
lab=0}
N 2710 2390 2710 2440 {
lab=#net2}
N 2630 2440 2710 2440 {
lab=#net2}
N 2840 2390 2840 2440 {
lab=VB1}
N 2840 2440 2930 2440 {
lab=VB1}
N 2670 2390 2710 2390 {
lab=#net2}
N 2840 2390 2890 2390 {
lab=VB1}
N 2630 2320 2630 2360 {
lab=VDD}
N 2930 2320 2930 2360 {
lab=VDD}
N 2550 2630 2590 2630 {
lab=VON}
N 3280 2630 3330 2630 {
lab=VOP}
N 2600 2320 2600 2390 {
lab=VDD}
N 2630 2320 2930 2320 {
lab=VDD}
N 2960 2320 2960 2390 {
lab=VDD}
N 2930 2320 2960 2320 {
lab=VDD}
N 2760 2920 2760 2990 {
lab=0}
N 2760 2990 2780 2990 {
lab=0}
N 3100 2920 3100 2990 {
lab=0}
N 3080 2990 3100 2990 {
lab=0}
N 540 2250 570 2250 {
lab=VDD}
N -310 2800 -220 2800 {
lab=P}
N 570 2370 570 2410 {
lab=A}
N 870 2370 870 2440 {
lab=#net1}
N -1980 2800 -1980 2880 {
lab=VB4}
N -1940 2950 -1920 2950 {
lab=VB4}
N -1690 2490 -1660 2490 {
lab=VB}
N -1730 2520 -1730 2540 {
lab=VB}
N -1690 2610 -1660 2610 {
lab=VB2}
N -1730 2640 -1730 2670 {
lab=VB2}
N -1480 2400 -1480 2490 {
lab=VDD}
N -1980 2400 -1750 2400 {
lab=VDD}
N -1750 2400 -1750 2490 {
lab=VDD}
N -1500 2640 -1500 2670 {
lab=VB3}
N -1500 2950 -1500 2980 {
lab=0}
N -1500 2760 -1500 2880 {
lab=D13}
N -220 2900 -220 2940 {
lab=0}
N 2630 2630 2780 2630 {
lab=0}
N 2780 2560 2930 2560 {
lab=VB1}
N 2630 2420 2630 2440 {
lab=#net2}
N 2930 2420 2930 2440 {
lab=VB1}
N 2600 2320 2630 2320 {
lab=VDD}
N -1980 3070 -1730 3070 {
lab=0}
N 870 2630 980 2630 {
lab=VOP}
N 470 2640 570 2640 {
lab=VON}
N -310 2410 -210 2410 {
lab=A}
N 140 2440 240 2440 {
lab=#net1}
N -220 3100 -120 3100 {
lab=0}
N -130 3100 180 3100 {
lab=0}
N -220 2410 110 2410 {
lab=A}
N -140 2440 150 2440 {
lab=#net1}
N -90 3100 290 3100 {
lab=0}
N -450 2370 -450 2540 {
lab=#net5}
N -450 2370 40 2370 {
lab=#net5}
N 40 2370 40 2550 {
lab=#net5}
N -550 2570 -490 2570 {
lab=INN}
N -550 2570 -550 2690 {
lab=INN}
N -550 2690 -400 2690 {
lab=INN}
N 80 2580 130 2580 {
lab=INN}
N 130 2580 130 2690 {
lab=INN}
N -60 2690 130 2690 {
lab=INN}
N -150 2350 -150 2370 {
lab=#net5}
N -150 2250 -150 2290 {
lab=VDD}
N -150 2250 540 2250 {
lab=VDD}
N -110 2320 -10 2320 {
lab=VB}
N -450 2600 -450 2920 {
lab=P1}
N -450 2920 570 2920 {
lab=P1}
N 40 2610 40 2780 {
lab=P2}
N 40 2780 40 2820 {
lab=P2}
N 40 2820 870 2820 {
lab=P2}
N -190 2320 -150 2320 {
lab=VDD}
N -190 2250 -190 2320 {
lab=VDD}
N -190 2250 -150 2250 {
lab=VDD}
N -450 2570 -390 2570 {
lab=VDD}
N -20 2580 40 2580 {
lab=VDD}
N 910 3100 1020 3100 {
lab=0}
N 900 2250 980 2250 {
lab=VDD}
N 1200 2530 1240 2530 {
lab=VB}
N 1280 2260 1280 2500 {
lab=VDD}
N 1260 2260 1280 2260 {
lab=VDD}
N 1280 2490 1280 2530 {
lab=VDD}
N 1280 2560 1280 2610 {
lab=VX}
N 1280 2670 1280 3110 {
lab=0}
N 1280 2580 1570 2580 {
lab=VX}
N 1210 2740 1410 2740 {
lab=VOP}
N 1450 2770 1450 2860 {
lab=VY}
N 1450 2920 1450 3110 {
lab=0}
N 1280 3110 1450 3110 {
lab=0}
N 1350 2890 1410 2890 {
lab=VB4}
N 1450 2890 1450 2920 {
lab=0}
N 1450 2740 1480 2740 {
lab=0}
N 1480 2740 1480 3110 {
lab=0}
N 1450 3110 1480 3110 {
lab=0}
N 1280 2260 1460 2260 {
lab=VDD}
N 1460 2260 1600 2260 {
lab=VDD}
N 1450 2260 1450 2710 {
lab=VDD}
N 1450 2810 1570 2810 {
lab=VY}
N 1610 2610 1610 2780 {
lab=OUT}
N 1610 2840 1610 3110 {
lab=0}
N 1480 3110 1610 3110 {
lab=0}
N 1610 2260 1610 2550 {
lab=VDD}
N 1600 2260 1610 2260 {
lab=VDD}
N 1610 2680 1750 2680 {
lab=OUT}
N 1610 2810 1630 2810 {
lab=0}
N 1630 2810 1630 2850 {
lab=0}
N 1610 2850 1630 2850 {
lab=0}
N 1610 2580 1640 2580 {
lab=VDD}
N 1640 2520 1640 2580 {
lab=VDD}
N 1610 2520 1640 2520 {
lab=VDD}
N 1280 2640 1300 2640 {
lab=VDD}
N 1300 2470 1300 2640 {
lab=VDD}
N 1280 2470 1300 2470 {
lab=VDD}
N 1750 2680 1870 2680 {
lab=OUT}
N 1610 3110 1750 3110 {
lab=0}
N 1750 3110 1870 3110 {
lab=0}
N 980 2630 1170 2630 {
lab=VOP}
N 1170 2630 1170 2640 {
lab=VOP}
N 1170 2640 1240 2640 {
lab=VOP}
N 1170 2640 1170 2740 {
lab=VOP}
N 1170 2740 1220 2740 {
lab=VOP}
N 1030 3100 1280 3100 {
lab=0}
N 990 3100 1050 3100 {
lab=0}
N 960 2250 1260 2260 {
lab=VDD}
N 1870 2700 1870 2740 {
lab=OUT}
N 1990 2700 1990 2740 {
lab=OUT}
N 1870 2800 1870 3080 {
lab=0}
N 1990 2800 1990 3080 {
lab=0}
N 1990 2680 1990 2700 {
lab=OUT}
N 1870 2680 1870 2700 {
lab=OUT}
N 1870 2680 1990 2680 {
lab=OUT}
N 1870 3070 1870 3110 {
lab=0}
N 1990 3080 1990 3110 {
lab=0}
N 1870 3110 1990 3110 {
lab=0}
N -2605 2180 -2605 2240 {
lab=VDD}
N -2735 2340 -2605 2340 {
lab=0}
N -2605 2300 -2605 2340 {
lab=0}
N -2535 2180 -2535 2240 {
lab=VCM}
N -2535 2300 -2535 2340 {
lab=0}
N -2535 2340 -2350 2340 {
lab=0}
N -2350 2190 -2350 2240 {
lab=INN}
N -2350 2300 -2350 2340 {
lab=0}
N -2605 2340 -2535 2340 {
lab=0}
N -380 2610 -380 2690 {
lab=INN}
N -380 2610 -70 2610 {
lab=INN}
N -70 2610 -70 2690 {
lab=INN}
N -2730 2190 -2730 2240 {
lab=INN}
N -2730 2300 -2730 2340 {
lab=0}
C {devices/code_shown.sym} 90 510 0 0 {name=NGSPICE1
only_toplevel=true
value="* this option enables mos model bin 
* selection based on W/NF instead of W
.option wnflag=1 
.option savecurrents

.control
save all
save @m.xm15.msky130_fd_pr__pfet_g5v0d10v5[vth]
save @m.xm15.msky130_fd_pr__pfet_g5v0d10v5[gm]
save @m.xm9.msky130_fd_pr__pfet_g5v0d10v5[vth]
save @m.xm9.msky130_fd_pr__pfet_g5v0d10v5[gm]
save @m.xm8.msky130_fd_pr__pfet_g5v0d10v5[vth]
save @m.xm8.msky130_fd_pr__pfet_g5v0d10v5[gm]
save @m.xm20.msky130_fd_pr__pfet_g5v0d10v5[vth]
save @m.xm20.msky130_fd_pr__pfet_g5v0d10v5[gm]
save @m.xm7.msky130_fd_pr__pfet_g5v0d10v5[vth]
save @m.xm7.msky130_fd_pr__pfet_g5v0d10v5[gm]
save @m.xm10.msky130_fd_pr__nfet_g5v0d10v5[gm]
save @m.xm10.msky130_fd_pr__nfet_g5v0d10v5[vth]
save @m.xm14.msky130_fd_pr__pfet_g5v0d10v5[gm]
save @m.xm14.msky130_fd_pr__pfet_g5v0d10v5[vth]
save @m.xm16.msky130_fd_pr__pfet_g5v0d10v5[gm]
save @m.xm16.msky130_fd_pr__pfet_g5v0d10v5[vth]
save @m.xm17.msky130_fd_pr__pfet_g5v0d10v5[gm]
save @m.xm17.msky130_fd_pr__pfet_g5v0d10v5[vth]
save @m.xm13.msky130_fd_pr__nfet_g5v0d10v5[gm]
save @m.xm13.msky130_fd_pr__nfet_g5v0d10v5[vth]
save @m.xm12.msky130_fd_pr__nfet_g5v0d10v5[vth]
save @m.xm18.msky130_fd_pr__nfet_g5v0d10v5[vth]
*folded 
save @m.xm2.msky130_fd_pr__nfet_g5v0d10v5[vth]
save @m.xm11.msky130_fd_pr__nfet_g5v0d10v5[vth]
save @m.xm1.msky130_fd_pr__nfet_g5v0d10v5[vth]
save @m.xm5.msky130_fd_pr__nfet_g5v0d10v5[vth]
save @m.xm6.msky130_fd_pr__nfet_g5v0d10v5[vth]
save @m.xm4.msky130_fd_pr__nfet_g5v0d10v5[vth]
save @m.xm3.msky130_fd_pr__nfet_g5v0d10v5[vth]
save @m.xm7.msky130_fd_pr__pfet_g5v0d10v5[vth]
save @m.xm8.msky130_fd_pr__pfet_g5v0d10v5[vth]
save @m.xm9.msky130_fd_pr__pfet_g5v0d10v5[vth]
save @m.xm20.msky130_fd_pr__pfet_g5v0d10v5[vth]
*CMFB
save @m.xm21.msky130_fd_pr__pfet_g5v0d10v5[vth]
save @m.xm19.msky130_fd_pr__pfet_g5v0d10v5[vth]
save @m.xm22.msky130_fd_pr__nfet_g5v0d10v5[vth]
save @m.xm23.msky130_fd_pr__nfet_g5v0d10v5[vth]
save @m.xm25.msky130_fd_pr__nfet_g5v0d10v5[vth]
save @m.xm27.msky130_fd_pr__nfet_g5v0d10v5[vth]
save @m.xm26.msky130_fd_pr__nfet_g5v0d10v5[vth]
save @m.xm24.msky130_fd_pr__nfet_g5v0d10v5[vth]
save current 


write Folded_Buffer.raw

op
print VON VOP VB2 VB VX OUT VY
*print @m.xm18.msky130_fd_pr__nfet_g5v0d10v5
*print @m.xm12.msky130_fd_pr__nfet_g5v0d10v5
*print @m.xm13.msky130_fd_pr__nfet_g5v0d10v5
*print @m.xm10.msky130_fd_pr__nfet_g5v0d10v5
*print @m.xm14.msky130_fd_pr__pfet_g5v0d10v5
*print @m.xm17.msky130_fd_pr__pfet_g5v0d10v5
*print @m.xm15.msky130_fd_pr__pfet_g5v0d10v5
*print @m.xm16.msky130_fd_pr__pfet_g5v0d10v5
*Folded cascode 
*print @m.xm9.msky130_fd_pr__pfet_g5v0d10v5
*print @m.xm8.msky130_fd_pr__pfet_g5v0d10v5
*print @m.xm5.msky130_fd_pr__nfet_g5v0d10v5
*print @m.xm4.msky130_fd_pr__nfet_g5v0d10v5
*print @m.xm1.msky130_fd_pr__nfet_g5v0d10v5
*print @m.xm2.msky130_fd_pr__nfet_g5v0d10v5
*print @m.xm11.msky130_fd_pr__nfet_g5v0d10v5
*CMFB
*print @m.xm23.msky130_fd_pr__nfet_g5v0d10v5
*print @m.xm24.msky130_fd_pr__nfet_g5v0d10v5
*print @m.xm25.msky130_fd_pr__nfet_g5v0d10v5
*print @m.xm22.msky130_fd_pr__nfet_g5v0d10v5
print @m.xm77.msky130_fd_pr__pfet_g5v0d10v5
print @m.xm76.msky130_fd_pr__pfet_g5v0d10v5
print @m.xm78.msky130_fd_pr__nfet_g5v0d10v5
print @m.xm79.msky130_fd_pr__nfet_g5v0d10v5
print @m.xm80.msky130_fd_pr__nfet_g5v0d10v5
print @m.xm81.msky130_fd_pr__pfet_g5v0d10v5
write Folded_Buffer.raw
ac dec 10 1 1e9
  remzerovec
  write tb_CMRR_MEAS_final.raw
quit 0
.endc
" }
C {sky130_fd_pr/corner.sym} -3315 325 0 0 {name=CORNER1 only_toplevel=true corner=tt}
C {devices/isource.sym} -2220 -170 0 0 {name=I1 value=5u
}
C {devices/lab_pin.sym} -2080 10 0 0 {name=p53 sig_type=std_logic lab=VB4
}
C {devices/lab_pin.sym} -550 -70 0 0 {name=p54 sig_type=std_logic lab=VB4}
C {devices/lab_pin.sym} 490 40 0 0 {name=p55 sig_type=std_logic lab=VB4}
C {devices/lab_pin.sym} -460 -250 0 0 {name=p56 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} -2090 130 1 0 {name=p57 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} -2090 -540 1 0 {name=p58 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 430 -690 1 0 {name=p59 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 480 -600 1 0 {name=p60 sig_type=std_logic lab=VB1}
C {devices/lab_pin.sym} -1820 -330 1 0 {name=p61 sig_type=std_logic lab=VB2}
C {devices/lab_pin.sym} 490 -460 3 0 {name=p62 sig_type=std_logic lab=VB2}
C {devices/lab_pin.sym} -1650 -250 2 0 {name=p63 sig_type=std_logic lab=VB3}
C {devices/lab_pin.sym} 490 -170 1 0 {name=p64 sig_type=std_logic lab=VB3}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} -1720 -20 0 1 {name=M44
L=5
W=8
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} -1990 10 0 0 {name=M45
L=12
W=2
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} -2200 10 0 1 {name=M46
L=12
W=2
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} -1950 -330 0 1 {name=M47
L=18
W=10
nf=1
mult=32
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} -1950 -450 0 1 {name=M48
L=2
W=10
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} -1760 -450 0 0 {name=M49
L=2
W=10
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} -1760 -330 0 0 {name=M50
L=18
W=10
nf=1
mult=32
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} -1740 -390 0 0 {name=p65 sig_type=std_logic lab=D17}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} -480 -70 0 0 {name=M51
L=12
W=2
nf=1
mult=160
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} -570 -250 0 0 {name=M52
L=1
W=20
nf=10
mult=20
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} -360 -250 0 1 {name=M53
L=1
W=20
nf=10
mult=20
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 610 -600 0 0 {name=M54
L=16
W=2
nf=1
mult=164
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 350 -600 0 1 {name=M55
L=16
W=2
nf=1
mult=164
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 610 -460 0 0 {name=M56
L=18
W=10
nf=1
mult=32
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 350 -460 0 1 {name=M57
L=18
W=10
nf=1
mult=32
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 610 40 0 0 {name=M58
L=12
W=2
nf=1
mult=82
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 350 40 0 1 {name=M59
L=12
W=2
nf=1
mult=82
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 350 -170 0 1 {name=M60
L=10
W=4
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 610 -170 0 0 {name=M61
L=10
W=4
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} -380 -170 0 0 {name=p66 sig_type=std_logic lab=P}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} -1720 -210 0 1 {name=M62
L=10
W=4
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} -1740 -110 0 1 {name=p67 sig_type=std_logic lab=D13}
C {devices/lab_pin.sym} 140 -530 1 0 {name=p68 sig_type=std_logic lab=A}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 2670 -550 0 0 {name=M63
L=16
W=2
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 2410 -550 0 1 {name=M64
L=16
W=2
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 2560 -310 0 1 {name=M65
L=12
W=4
nf=2
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 3020 -310 0 1 {name=M66
L=12
W=4
nf=2
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 2370 -310 0 0 {name=M67
L=12
W=4
nf=2
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 2710 -20 0 0 {name=p69 sig_type=std_logic lab=VB4}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 2820 -20 0 0 {name=M68
L=12
W=2
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 2560 -20 0 1 {name=M69
L=12
W=2
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 330 -320 0 0 {name=p70 sig_type=std_logic lab=VON}
C {devices/lab_pin.sym} 630 -320 2 0 {name=p71 sig_type=std_logic lab=VOP}
C {devices/lab_pin.sym} 2470 -310 1 0 {name=p72 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 2310 -310 0 0 {name=p73 sig_type=std_logic lab=VON}
C {devices/lab_pin.sym} 3090 -310 0 1 {name=p74 sig_type=std_logic lab=VOP}
C {devices/lab_pin.sym} 2930 -310 1 0 {name=p75 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 2730 -310 1 0 {name=p76 sig_type=std_logic lab=VCM}
C {devices/lab_pin.sym} 2730 50 1 0 {name=p77 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 2590 -620 1 0 {name=p78 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2600 -530 0 0 {name=p79 sig_type=std_logic lab=VB1}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 2820 -310 0 0 {name=M70
L=12
W=4
nf=2
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} -1850 -450 1 0 {name=p80 sig_type=std_logic lab=VB}
C {devices/lab_pin.sym} 330 -80 0 0 {name=p81 sig_type=std_logic lab=P1}
C {devices/lab_pin.sym} 630 -80 0 0 {name=p82 sig_type=std_logic lab=P2}
C {devices/lab_pin.sym} -650 -250 1 0 {name=p83 sig_type=std_logic lab=INN}
C {devices/lab_pin.sym} -250 160 1 0 {name=p84 sig_type=std_logic lab=0}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} -180 -360 0 1 {name=M71
L=10
W=10
nf=1
mult=20
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} -710 -370 0 0 {name=M72
L=10
W=10
nf=1
mult=20
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} -370 -620 0 1 {name=M73
L=2
W=10
nf=1
mult=160
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} -270 -620 1 0 {name=p86 sig_type=std_logic lab=VB}
C {devices/lab_pin.sym} -630 -370 1 0 {name=p87 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -260 -360 1 0 {name=p88 sig_type=std_logic lab=VDD}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 1020 -300 0 0 {name=M76
L=20
W=9.5
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 1020 -410 0 0 {name=M77
L=19
W=10
nf=2
mult=20
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 1190 -200 0 0 {name=M78
L=20
W=10
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 1190 -50 0 0 {name=M79
L=20
W=11
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 1350 -130 0 0 {name=M80
L=20
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 1350 -360 0 0 {name=M81
L=0.8
W=19
nf=2
mult=200
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 1110 -50 0 0 {name=p91 sig_type=std_logic lab=VB4}
C {devices/lab_pin.sym} 1510 -260 0 0 {name=p92 sig_type=std_logic lab=OUT}
C {devices/lab_pin.sym} 1170 -360 1 0 {name=p93 sig_type=std_logic lab=VX}
C {devices/lab_pin.sym} 1130 -200 1 0 {name=p94 sig_type=std_logic lab=VOP}
C {devices/lab_pin.sym} 1290 -130 0 0 {name=p95 sig_type=std_logic lab=VY}
C {devices/lab_pin.sym} 960 -410 0 0 {name=p1 sig_type=std_logic lab=VB}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1750 -170 0 0 {name=C1 model=cap_mim_m3_1 W=10000 L=1.3 MF=1 spiceprefix=X}
C {sky130_fd_pr/res_generic_l1.sym} 1630 -170 0 0 {name=R1
W=1
L=410
model=res_generic_l1
mult=1}
C {devices/vsource.sym} -2845 -670 0 0 {name=V4 value=5 savecurrent=false}
C {devices/lab_pin.sym} -2845 -740 0 0 {name=p22 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -2875 -600 1 0 {name=p26 sig_type=std_logic lab=0}
C {devices/vsource.sym} -2775 -670 0 0 {name=V1 value=2.5 savecurrent=false}
C {devices/lab_pin.sym} -2775 -740 0 0 {name=p34 sig_type=std_logic lab=VCM}
C {devices/vsource.sym} -2590 -670 0 0 {name=V3 value="dc 2.5 ac 1u 0"  net_name=true}
C {devices/lab_pin.sym} -2590 -730 0 0 {name=p23 sig_type=std_logic lab=INN}
C {sky130_fd_pr/corner.sym} -3075 3265 0 0 {name=CORNER2 only_toplevel=true corner=tt}
C {devices/isource.sym} -1980 2770 0 0 {name=I2 value=5u
}
C {devices/lab_pin.sym} -1840 2950 0 0 {name=p2 sig_type=std_logic lab=VB4
}
C {devices/lab_pin.sym} -310 2870 0 0 {name=p3 sig_type=std_logic lab=VB4}
C {devices/lab_pin.sym} 730 2980 0 0 {name=p4 sig_type=std_logic lab=VB4}
C {devices/lab_pin.sym} -220 2690 0 0 {name=p5 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} -1850 3070 1 0 {name=p6 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} -1850 2400 1 0 {name=p7 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 670 2250 1 0 {name=p8 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 720 2340 1 0 {name=p9 sig_type=std_logic lab=VB1}
C {devices/lab_pin.sym} -1580 2610 1 0 {name=p10 sig_type=std_logic lab=VB2}
C {devices/lab_pin.sym} 730 2480 3 0 {name=p11 sig_type=std_logic lab=VB2}
C {devices/lab_pin.sym} -1410 2690 2 0 {name=p12 sig_type=std_logic lab=VB3}
C {devices/lab_pin.sym} 730 2770 1 0 {name=p13 sig_type=std_logic lab=VB3}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} -1480 2920 0 1 {name=M1
L=5
W=8
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} -1750 2950 0 0 {name=M2
L=12
W=2
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} -1960 2950 0 1 {name=M3
L=12
W=2
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} -1710 2610 0 1 {name=M4
L=18
W=10
nf=1
mult=32
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} -1710 2490 0 1 {name=M5
L=2
W=10
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} -1520 2490 0 0 {name=M6
L=2
W=10
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} -1520 2610 0 0 {name=M7
L=18
W=10
nf=1
mult=32
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} -1500 2550 0 0 {name=p14 sig_type=std_logic lab=D17}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} -240 2870 0 0 {name=M8
L=12
W=2
nf=1
mult=160
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} -330 2690 0 0 {name=M9
L=1
W=20
nf=10
mult=20
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} -120 2690 0 1 {name=M10
L=1
W=20
nf=10
mult=20
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 850 2340 0 0 {name=M11
L=16
W=2
nf=1
mult=164
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 590 2340 0 1 {name=M12
L=16
W=2
nf=1
mult=164
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 850 2480 0 0 {name=M13
L=18
W=10
nf=1
mult=32
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 590 2480 0 1 {name=M14
L=18
W=10
nf=1
mult=32
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 850 2980 0 0 {name=M15
L=12
W=2
nf=1
mult=82
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 590 2980 0 1 {name=M16
L=12
W=2
nf=1
mult=82
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 590 2770 0 1 {name=M17
L=10
W=4
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 850 2770 0 0 {name=M18
L=10
W=4
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} -140 2770 0 0 {name=p15 sig_type=std_logic lab=P}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} -1480 2730 0 1 {name=M19
L=10
W=4
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} -1500 2830 0 1 {name=p16 sig_type=std_logic lab=D13}
C {devices/lab_pin.sym} 380 2410 1 0 {name=p17 sig_type=std_logic lab=A}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 2910 2390 0 0 {name=M20
L=16
W=2
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 2650 2390 0 1 {name=M21
L=16
W=2
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 2800 2630 0 1 {name=M22
L=12
W=4
nf=2
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 3260 2630 0 1 {name=M23
L=12
W=4
nf=2
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 2610 2630 0 0 {name=M24
L=12
W=4
nf=2
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 2950 2920 0 0 {name=p18 sig_type=std_logic lab=VB4}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 3060 2920 0 0 {name=M25
L=12
W=2
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 2800 2920 0 1 {name=M26
L=12
W=2
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 570 2620 0 0 {name=p19 sig_type=std_logic lab=VON}
C {devices/lab_pin.sym} 870 2620 2 0 {name=p20 sig_type=std_logic lab=VOP}
C {devices/lab_pin.sym} 2710 2630 1 0 {name=p21 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 2550 2630 0 0 {name=p24 sig_type=std_logic lab=VON}
C {devices/lab_pin.sym} 3330 2630 0 1 {name=p25 sig_type=std_logic lab=VOP}
C {devices/lab_pin.sym} 3170 2630 1 0 {name=p27 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 2970 2630 1 0 {name=p28 sig_type=std_logic lab=VCM}
C {devices/lab_pin.sym} 2970 2990 1 0 {name=p29 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 2830 2320 1 0 {name=p30 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 2840 2410 0 0 {name=p31 sig_type=std_logic lab=VB1}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 3060 2630 0 0 {name=M27
L=12
W=4
nf=2
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} -1610 2490 1 0 {name=p32 sig_type=std_logic lab=VB}
C {devices/lab_pin.sym} 570 2860 0 0 {name=p33 sig_type=std_logic lab=P1}
C {devices/lab_pin.sym} 870 2860 0 0 {name=p35 sig_type=std_logic lab=P2}
C {devices/lab_pin.sym} -410 2690 1 0 {name=p36 sig_type=std_logic lab=INN}
C {devices/lab_pin.sym} -10 3100 1 0 {name=p37 sig_type=std_logic lab=0}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 60 2580 0 1 {name=M28
L=10
W=10
nf=1
mult=20
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} -470 2570 0 0 {name=M29
L=10
W=10
nf=1
mult=20
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} -130 2320 0 1 {name=M30
L=2
W=10
nf=1
mult=160
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} -30 2320 1 0 {name=p38 sig_type=std_logic lab=VB}
C {devices/lab_pin.sym} -390 2570 1 0 {name=p39 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -20 2580 1 0 {name=p40 sig_type=std_logic lab=VDD}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 1260 2640 0 0 {name=M31
L=20
W=9.5
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 1260 2530 0 0 {name=M32
L=19
W=10
nf=2
mult=20
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 1430 2740 0 0 {name=M33
L=20
W=10
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 1430 2890 0 0 {name=M34
L=20
W=11
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 1590 2810 0 0 {name=M35
L=20
W=1
nf=1
mult=1
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 1590 2580 0 0 {name=M36
L=0.8
W=19
nf=2
mult=200
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 1350 2890 0 0 {name=p41 sig_type=std_logic lab=VB4}
C {devices/lab_pin.sym} 1750 2680 0 0 {name=p42 sig_type=std_logic lab=OUT}
C {devices/lab_pin.sym} 1410 2580 1 0 {name=p43 sig_type=std_logic lab=VX}
C {devices/lab_pin.sym} 1370 2740 1 0 {name=p44 sig_type=std_logic lab=VOP}
C {devices/lab_pin.sym} 1530 2810 0 0 {name=p45 sig_type=std_logic lab=VY}
C {devices/lab_pin.sym} 1200 2530 0 0 {name=p46 sig_type=std_logic lab=VB}
C {sky130_fd_pr/cap_mim_m3_1.sym} 1990 2770 0 0 {name=C2 model=cap_mim_m3_1 W=10000 L=1.3 MF=1 spiceprefix=X}
C {sky130_fd_pr/res_generic_l1.sym} 1870 2770 0 0 {name=R2
W=1
L=410
model=res_generic_l1
mult=1}
C {devices/vsource.sym} -2605 2270 0 0 {name=V2 value=5 savecurrent=false}
C {devices/lab_pin.sym} -2605 2200 0 0 {name=p47 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -2635 2340 1 0 {name=p48 sig_type=std_logic lab=0}
C {devices/vsource.sym} -2535 2270 0 0 {name=V5 value=2.5 savecurrent=false}
C {devices/lab_pin.sym} -2535 2200 0 0 {name=p49 sig_type=std_logic lab=VCM}
C {devices/vsource.sym} -2350 2270 0 0 {name=V6 value="dc 2.5 ac 1u 0"  net_name=true}
C {devices/lab_pin.sym} -2350 2210 0 0 {name=p50 sig_type=std_logic lab=INN}
C {devices/vsource.sym} -2730 2270 0 0 {name=V7 value="dc 2.5 ac 1u 180"  net_name=true}
C {devices/lab_pin.sym} -2730 2210 0 0 {name=p51 sig_type=std_logic lab=INP}
