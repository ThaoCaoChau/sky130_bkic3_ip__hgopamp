v {xschem version=3.4.5 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
B 2 -1360 -1930 410 -1080 {flags=graph
y1=98.348285

ypos1=0
ypos2=2


unity=1


divx=5
subdivx=8
xlabmag=1.0
ylabmag=1.0


dataset=-1
unitx=1
logx=1
logy=0
color=4
node="\\"VOP db20()\\""
x1=0.36279525
hilight_wave=-1

y2=100.97081

divy=10
subdivy=4
x2=1.7117105}
N 600 -670 600 -610 {
lab=VDD}
N 900 -670 900 -610 {
lab=VDD}
N 900 -480 900 -470 {
lab=#net1}
N 600 -510 600 -470 {
lab=A}
N 600 -410 600 -180 {
lab=VON}
N 600 -120 600 30 {
lab=P1}
N 600 90 600 180 {
lab=0}
N 600 180 900 180 {
lab=0}
N 900 90 900 180 {
lab=0}
N 900 -120 900 30 {
lab=P2}
N 900 -410 900 -180 {
lab=VOP}
N 640 -150 860 -150 {
lab=VB3}
N 640 60 860 60 {
lab=VB4}
N 570 60 600 60 {
lab=0}
N 570 60 570 180 {
lab=0}
N 570 180 600 180 {
lab=0}
N 900 60 940 60 {
lab=0}
N 940 60 940 180 {
lab=0}
N 900 180 940 180 {
lab=0}
N 570 -150 600 -150 {
lab=0}
N 570 -150 570 60 {
lab=0}
N 900 -150 940 -150 {
lab=0}
N 940 -150 940 60 {
lab=0}
N -280 -230 -110 -230 {
lab=0}
N -370 -230 -320 -230 {
lab=INN}
N -70 -230 -30 -230 {
lab=INP}
N -280 -200 -280 -120 {
lab=P}
N -190 -120 -110 -120 {
lab=P}
N -110 -200 -110 -120 {
lab=P}
N -190 -120 -190 -80 {
lab=P}
N -290 -50 -230 -50 {
lab=VB4}
N -190 20 -190 180 {
lab=0}
N 190 180 570 180 {
lab=0}
N 640 -440 860 -440 {
lab=VB2}
N 640 -580 860 -580 {
lab=VB1}
N 900 -580 930 -580 {
lab=VDD}
N 930 -670 930 -580 {
lab=VDD}
N 900 -670 930 -670 {
lab=VDD}
N 570 -580 600 -580 {
lab=VDD}
N 570 -670 570 -580 {
lab=VDD}
N 600 -670 900 -670 {
lab=VDD}
N 900 -440 930 -440 {
lab=VDD}
N 930 -580 930 -440 {
lab=VDD}
N 570 -440 600 -440 {
lab=VDD}
N 570 -580 570 -440 {
lab=VDD}
N -280 -510 -280 -260 {
lab=A}
N 100 -510 600 -510 {
lab=A}
N -110 -480 -110 -260 {
lab=#net1}
N 270 -480 900 -480 {
lab=#net1}
N -1950 -40 -1950 0 {
lab=VB4}
N -1950 60 -1950 150 {
lab=0}
N -1700 60 -1700 150 {
lab=0}
N -1700 30 -1670 30 {
lab=0}
N -1670 30 -1670 150 {
lab=0}
N -1700 150 -1670 150 {
lab=0}
N -1980 30 -1950 30 {
lab=0}
N -1980 30 -1980 150 {
lab=0}
N -1980 150 -1950 150 {
lab=0}
N -1890 30 -1740 30 {
lab=VB4}
N -1950 -40 -1890 -40 {
lab=VB4}
N -1890 -40 -1890 30 {
lab=VB4}
N -1700 -520 -1700 -460 {
lab=VDD}
N -1700 -520 -1470 -520 {
lab=VDD}
N -1470 -520 -1470 -460 {
lab=VDD}
N -1630 -430 -1510 -430 {
lab=VB}
N -1630 -430 -1630 -380 {
lab=VB}
N -1700 -380 -1630 -380 {
lab=VB}
N -1700 -380 -1700 -340 {
lab=VB}
N -1950 -520 -1950 -180 {
lab=VDD}
N -1720 -520 -1700 -520 {
lab=VDD}
N -1700 -250 -1700 0 {
lab=VB2}
N -1630 -310 -1510 -310 {
lab=VB2}
N -1630 -310 -1630 -250 {
lab=VB2}
N -1700 -250 -1630 -250 {
lab=VB2}
N -1470 -400 -1470 -340 {
lab=D17}
N -1470 -310 -1450 -310 {
lab=VDD}
N -1450 -430 -1450 -310 {
lab=VDD}
N -1470 -520 -1450 -520 {
lab=VDD}
N -1470 -430 -1450 -430 {
lab=VDD}
N -1720 -310 -1700 -310 {
lab=VDD}
N -1720 -430 -1720 -310 {
lab=VDD}
N -1720 -430 -1700 -430 {
lab=VDD}
N -1470 -250 -1470 -220 {
lab=VB3}
N -1470 -40 -1470 -30 {
lab=D13}
N -1430 -190 -1380 -190 {
lab=VB3}
N -1380 -250 -1380 -190 {
lab=VB3}
N -1470 -250 -1380 -250 {
lab=VB3}
N -1470 60 -1470 150 {
lab=0}
N -1670 150 -1470 150 {
lab=0}
N -1490 0 -1470 0 {
lab=0}
N -1490 0 -1490 60 {
lab=0}
N -1490 60 -1470 60 {
lab=0}
N -1430 0 -1400 0 {
lab=D13}
N -1400 -40 -1400 0 {
lab=D13}
N -1470 -40 -1400 -40 {
lab=D13}
N -190 -50 -140 -50 {
lab=0}
N -140 -50 -140 20 {
lab=0}
N -190 20 -140 20 {
lab=0}
N -1490 -190 -1490 0 {
lab=0}
N -1490 -190 -1470 -190 {
lab=0}
N 2060 -570 2090 -570 {
lab=VDD}
N 1730 -570 1760 -570 {
lab=VDD}
N 1950 -330 2170 -330 {
lab=VCM}
N 2210 -330 2370 -330 {
lab=0}
N 1890 -40 1920 -40 {
lab=0}
N 2210 -40 2230 -40 {
lab=0}
N 1910 -400 1910 -360 {
lab=VB1}
N 2060 -400 2210 -400 {
lab=VB1}
N 2210 -400 2210 -360 {
lab=VB1}
N 1760 -460 1760 -360 {
lab=#net2}
N 1760 -460 2370 -460 {
lab=#net2}
N 2370 -460 2370 -360 {
lab=#net2}
N 1760 -520 1760 -460 {
lab=#net2}
N 2060 -520 2060 -400 {
lab=VB1}
N 1760 -300 1760 -260 {
lab=#net3}
N 1760 -260 1910 -260 {
lab=#net3}
N 1910 -300 1910 -260 {
lab=#net3}
N 2210 -300 2210 -260 {
lab=#net4}
N 2210 -260 2370 -260 {
lab=#net4}
N 2370 -300 2370 -260 {
lab=#net4}
N 1910 -260 1910 -70 {
lab=#net3}
N 2210 -260 2210 -70 {
lab=#net4}
N 1950 -40 2180 -40 {
lab=VB4}
N 1910 -10 1910 30 {
lab=0}
N 1910 30 2210 30 {
lab=0}
N 2210 -10 2210 30 {
lab=0}
N 1840 -570 1840 -520 {
lab=#net2}
N 1760 -520 1840 -520 {
lab=#net2}
N 1970 -570 1970 -520 {
lab=VB1}
N 1970 -520 2060 -520 {
lab=VB1}
N 1800 -570 1840 -570 {
lab=#net2}
N 1970 -570 2020 -570 {
lab=VB1}
N 1760 -640 1760 -600 {
lab=VDD}
N 2060 -640 2060 -600 {
lab=VDD}
N 1680 -330 1720 -330 {
lab=VON}
N 2410 -330 2460 -330 {
lab=VOP}
N 1730 -640 1730 -570 {
lab=VDD}
N 1760 -640 2060 -640 {
lab=VDD}
N 2090 -640 2090 -570 {
lab=VDD}
N 2060 -640 2090 -640 {
lab=VDD}
N 1890 -40 1890 30 {
lab=0}
N 1890 30 1910 30 {
lab=0}
N 2230 -40 2230 30 {
lab=0}
N 2210 30 2230 30 {
lab=0}
N 570 -670 600 -670 {
lab=VDD}
N -280 -120 -190 -120 {
lab=P}
N 600 -550 600 -510 {
lab=A}
N 900 -550 900 -480 {
lab=#net1}
N -1950 -120 -1950 -40 {
lab=VB4}
N -1910 30 -1890 30 {
lab=VB4}
N -1660 -430 -1630 -430 {
lab=VB}
N -1700 -400 -1700 -380 {
lab=VB}
N -1660 -310 -1630 -310 {
lab=VB2}
N -1700 -280 -1700 -250 {
lab=VB2}
N -1450 -520 -1450 -430 {
lab=VDD}
N -1950 -520 -1720 -520 {
lab=VDD}
N -1720 -520 -1720 -430 {
lab=VDD}
N -1470 -280 -1470 -250 {
lab=VB3}
N -1470 30 -1470 60 {
lab=0}
N -1470 -160 -1470 -40 {
lab=D13}
N -190 -20 -190 20 {
lab=0}
N 1760 -330 1910 -330 {
lab=0}
N 1910 -400 2060 -400 {
lab=VB1}
N 1760 -540 1760 -520 {
lab=#net2}
N 2060 -540 2060 -520 {
lab=VB1}
N 1730 -640 1760 -640 {
lab=VDD}
N -1950 150 -1700 150 {
lab=0}
N 900 -290 1010 -290 {
lab=VOP}
N 500 -280 600 -280 {
lab=VON}
N -280 -510 -180 -510 {
lab=A}
N 170 -480 270 -480 {
lab=#net1}
N -190 180 -90 180 {
lab=0}
N -100 180 210 180 {
lab=0}
N -190 -510 140 -510 {
lab=A}
N -110 -480 180 -480 {
lab=#net1}
N -60 180 320 180 {
lab=0}
N -420 -550 -420 -380 {
lab=#net5}
N -420 -550 70 -550 {
lab=#net5}
N 70 -550 70 -370 {
lab=#net5}
N -520 -350 -460 -350 {
lab=INN}
N -520 -350 -520 -230 {
lab=INN}
N -520 -230 -370 -230 {
lab=INN}
N 110 -340 160 -340 {
lab=INP}
N 160 -340 160 -230 {
lab=INP}
N -30 -230 160 -230 {
lab=INP}
N -120 -570 -120 -550 {
lab=#net5}
N -120 -670 -120 -630 {
lab=VDD}
N -120 -670 570 -670 {
lab=VDD}
N -80 -600 20 -600 {
lab=VB}
N -420 -320 -420 0 {
lab=P1}
N -420 0 600 0 {
lab=P1}
N 70 -310 70 -140 {
lab=P2}
N 70 -140 70 -100 {
lab=P2}
N 70 -100 900 -100 {
lab=P2}
N -160 -600 -120 -600 {
lab=VDD}
N -160 -670 -160 -600 {
lab=VDD}
N -160 -670 -120 -670 {
lab=VDD}
N -420 -350 -360 -350 {
lab=VDD}
N 10 -340 70 -340 {
lab=VDD}
N 1050 -290 1080 -290 {
lab=0}
N 1080 -290 1100 -290 {
lab=0}
N 1050 -670 1050 -320 {
lab=VDD}
N 1010 -670 1050 -670 {
lab=VDD}
N 1050 -260 1050 -200 {
lab=#net6}
N 1050 -140 1050 180 {
lab=0}
N 1100 -290 1100 170 {
lab=0}
N 1100 170 1100 180 {
lab=0}
N 1050 180 1100 180 {
lab=0}
N 940 180 1050 180 {
lab=0}
N 930 -670 1010 -670 {
lab=VDD}
N 460 -390 460 -310 {
lab=VDD}
N 430 -280 460 -280 {
lab=0}
N 430 -280 430 170 {
lab=0}
N 430 170 430 180 {
lab=0}
N 460 -250 460 -200 {
lab=#net7}
N 460 -140 460 180 {
lab=0}
N -15 660 -15 720 {
lab=VDD}
N -145 820 -15 820 {
lab=0}
N -15 780 -15 820 {
lab=0}
N 55 660 55 720 {
lab=VCM}
N 55 780 55 820 {
lab=0}
N 55 820 240 820 {
lab=0}
N 240 670 240 720 {
lab=INN}
N 240 780 240 820 {
lab=0}
N -15 820 55 820 {
lab=0}
N -140 670 -140 720 {
lab=INP}
N -140 780 -140 820 {
lab=0}
N 580 1410 580 1470 {
lab=VDD}
N 880 1410 880 1470 {
lab=VDD}
N 880 1600 880 1610 {
lab=#net1}
N 580 1570 580 1610 {
lab=A}
N 580 1670 580 1900 {
lab=VON}
N 580 1960 580 2110 {
lab=P1}
N 580 2170 580 2260 {
lab=0}
N 580 2260 880 2260 {
lab=0}
N 880 2170 880 2260 {
lab=0}
N 880 1960 880 2110 {
lab=P2}
N 880 1670 880 1900 {
lab=VOP}
N 620 1930 840 1930 {
lab=VB3}
N 620 2140 840 2140 {
lab=VB4}
N 550 2140 580 2140 {
lab=0}
N 550 2140 550 2260 {
lab=0}
N 550 2260 580 2260 {
lab=0}
N 880 2140 920 2140 {
lab=0}
N 920 2140 920 2260 {
lab=0}
N 880 2260 920 2260 {
lab=0}
N 550 1930 580 1930 {
lab=0}
N 550 1930 550 2140 {
lab=0}
N 880 1930 920 1930 {
lab=0}
N 920 1930 920 2140 {
lab=0}
N -300 1850 -130 1850 {
lab=0}
N -390 1850 -340 1850 {
lab=INN}
N -90 1850 -50 1850 {
lab=INP}
N -300 1880 -300 1960 {
lab=P}
N -210 1960 -130 1960 {
lab=P}
N -130 1880 -130 1960 {
lab=P}
N -210 1960 -210 2000 {
lab=P}
N -310 2030 -250 2030 {
lab=VB4}
N -210 2100 -210 2260 {
lab=0}
N 170 2260 550 2260 {
lab=0}
N 620 1640 840 1640 {
lab=VB2}
N 620 1500 840 1500 {
lab=VB1}
N 880 1500 910 1500 {
lab=VDD}
N 910 1410 910 1500 {
lab=VDD}
N 880 1410 910 1410 {
lab=VDD}
N 550 1500 580 1500 {
lab=VDD}
N 550 1410 550 1500 {
lab=VDD}
N 580 1410 880 1410 {
lab=VDD}
N 880 1640 910 1640 {
lab=VDD}
N 910 1500 910 1640 {
lab=VDD}
N 550 1640 580 1640 {
lab=VDD}
N 550 1500 550 1640 {
lab=VDD}
N -300 1570 -300 1820 {
lab=A}
N 80 1570 580 1570 {
lab=A}
N -130 1600 -130 1820 {
lab=#net1}
N 250 1600 880 1600 {
lab=#net1}
N -1970 2040 -1970 2080 {
lab=VB4}
N -1970 2140 -1970 2230 {
lab=0}
N -1720 2140 -1720 2230 {
lab=0}
N -1720 2110 -1690 2110 {
lab=0}
N -1690 2110 -1690 2230 {
lab=0}
N -1720 2230 -1690 2230 {
lab=0}
N -2000 2110 -1970 2110 {
lab=0}
N -2000 2110 -2000 2230 {
lab=0}
N -2000 2230 -1970 2230 {
lab=0}
N -1910 2110 -1760 2110 {
lab=VB4}
N -1970 2040 -1910 2040 {
lab=VB4}
N -1910 2040 -1910 2110 {
lab=VB4}
N -1720 1560 -1720 1620 {
lab=VDD}
N -1720 1560 -1490 1560 {
lab=VDD}
N -1490 1560 -1490 1620 {
lab=VDD}
N -1650 1650 -1530 1650 {
lab=VB}
N -1650 1650 -1650 1700 {
lab=VB}
N -1720 1700 -1650 1700 {
lab=VB}
N -1720 1700 -1720 1740 {
lab=VB}
N -1970 1560 -1970 1900 {
lab=VDD}
N -1740 1560 -1720 1560 {
lab=VDD}
N -1720 1830 -1720 2080 {
lab=VB2}
N -1650 1770 -1530 1770 {
lab=VB2}
N -1650 1770 -1650 1830 {
lab=VB2}
N -1720 1830 -1650 1830 {
lab=VB2}
N -1490 1680 -1490 1740 {
lab=D17}
N -1490 1770 -1470 1770 {
lab=VDD}
N -1470 1650 -1470 1770 {
lab=VDD}
N -1490 1560 -1470 1560 {
lab=VDD}
N -1490 1650 -1470 1650 {
lab=VDD}
N -1740 1770 -1720 1770 {
lab=VDD}
N -1740 1650 -1740 1770 {
lab=VDD}
N -1740 1650 -1720 1650 {
lab=VDD}
N -1490 1830 -1490 1860 {
lab=VB3}
N -1490 2040 -1490 2050 {
lab=D13}
N -1450 1890 -1400 1890 {
lab=VB3}
N -1400 1830 -1400 1890 {
lab=VB3}
N -1490 1830 -1400 1830 {
lab=VB3}
N -1490 2140 -1490 2230 {
lab=0}
N -1690 2230 -1490 2230 {
lab=0}
N -1510 2080 -1490 2080 {
lab=0}
N -1510 2080 -1510 2140 {
lab=0}
N -1510 2140 -1490 2140 {
lab=0}
N -1450 2080 -1420 2080 {
lab=D13}
N -1420 2040 -1420 2080 {
lab=D13}
N -1490 2040 -1420 2040 {
lab=D13}
N -210 2030 -160 2030 {
lab=0}
N -160 2030 -160 2100 {
lab=0}
N -210 2100 -160 2100 {
lab=0}
N -1510 1890 -1510 2080 {
lab=0}
N -1510 1890 -1490 1890 {
lab=0}
N 2040 1510 2070 1510 {
lab=VDD}
N 1710 1510 1740 1510 {
lab=VDD}
N 1930 1750 2150 1750 {
lab=VCM}
N 2190 1750 2350 1750 {
lab=0}
N 1870 2040 1900 2040 {
lab=0}
N 2190 2040 2210 2040 {
lab=0}
N 1890 1680 1890 1720 {
lab=VB1}
N 2040 1680 2190 1680 {
lab=VB1}
N 2190 1680 2190 1720 {
lab=VB1}
N 1740 1620 1740 1720 {
lab=#net2}
N 1740 1620 2350 1620 {
lab=#net2}
N 2350 1620 2350 1720 {
lab=#net2}
N 1740 1560 1740 1620 {
lab=#net2}
N 2040 1560 2040 1680 {
lab=VB1}
N 1740 1780 1740 1820 {
lab=#net3}
N 1740 1820 1890 1820 {
lab=#net3}
N 1890 1780 1890 1820 {
lab=#net3}
N 2190 1780 2190 1820 {
lab=#net4}
N 2190 1820 2350 1820 {
lab=#net4}
N 2350 1780 2350 1820 {
lab=#net4}
N 1890 1820 1890 2010 {
lab=#net3}
N 2190 1820 2190 2010 {
lab=#net4}
N 1930 2040 2160 2040 {
lab=VB4}
N 1890 2070 1890 2110 {
lab=0}
N 1890 2110 2190 2110 {
lab=0}
N 2190 2070 2190 2110 {
lab=0}
N 1820 1510 1820 1560 {
lab=#net2}
N 1740 1560 1820 1560 {
lab=#net2}
N 1950 1510 1950 1560 {
lab=VB1}
N 1950 1560 2040 1560 {
lab=VB1}
N 1780 1510 1820 1510 {
lab=#net2}
N 1950 1510 2000 1510 {
lab=VB1}
N 1740 1440 1740 1480 {
lab=VDD}
N 2040 1440 2040 1480 {
lab=VDD}
N 1660 1750 1700 1750 {
lab=VON}
N 2390 1750 2440 1750 {
lab=VOP}
N 1710 1440 1710 1510 {
lab=VDD}
N 1740 1440 2040 1440 {
lab=VDD}
N 2070 1440 2070 1510 {
lab=VDD}
N 2040 1440 2070 1440 {
lab=VDD}
N 1870 2040 1870 2110 {
lab=0}
N 1870 2110 1890 2110 {
lab=0}
N 2210 2040 2210 2110 {
lab=0}
N 2190 2110 2210 2110 {
lab=0}
N 550 1410 580 1410 {
lab=VDD}
N -300 1960 -210 1960 {
lab=P}
N 580 1530 580 1570 {
lab=A}
N 880 1530 880 1600 {
lab=#net1}
N -1970 1960 -1970 2040 {
lab=VB4}
N -1930 2110 -1910 2110 {
lab=VB4}
N -1680 1650 -1650 1650 {
lab=VB}
N -1720 1680 -1720 1700 {
lab=VB}
N -1680 1770 -1650 1770 {
lab=VB2}
N -1720 1800 -1720 1830 {
lab=VB2}
N -1470 1560 -1470 1650 {
lab=VDD}
N -1970 1560 -1740 1560 {
lab=VDD}
N -1740 1560 -1740 1650 {
lab=VDD}
N -1490 1800 -1490 1830 {
lab=VB3}
N -1490 2110 -1490 2140 {
lab=0}
N -1490 1920 -1490 2040 {
lab=D13}
N -210 2060 -210 2100 {
lab=0}
N 1740 1750 1890 1750 {
lab=0}
N 1890 1680 2040 1680 {
lab=VB1}
N 1740 1540 1740 1560 {
lab=#net2}
N 2040 1540 2040 1560 {
lab=VB1}
N 1710 1440 1740 1440 {
lab=VDD}
N -1970 2230 -1720 2230 {
lab=0}
N 880 1790 990 1790 {
lab=VOP}
N 480 1800 580 1800 {
lab=VON}
N -300 1570 -200 1570 {
lab=A}
N 150 1600 250 1600 {
lab=#net1}
N -210 2260 -110 2260 {
lab=0}
N -120 2260 190 2260 {
lab=0}
N -210 1570 120 1570 {
lab=A}
N -130 1600 160 1600 {
lab=#net1}
N -80 2260 300 2260 {
lab=0}
N -440 1530 -440 1700 {
lab=#net5}
N -440 1530 50 1530 {
lab=#net5}
N 50 1530 50 1710 {
lab=#net5}
N -540 1730 -480 1730 {
lab=INN}
N -540 1730 -540 1850 {
lab=INN}
N -540 1850 -390 1850 {
lab=INN}
N 90 1740 140 1740 {
lab=INP}
N 140 1740 140 1850 {
lab=INP}
N -50 1850 140 1850 {
lab=INP}
N -140 1510 -140 1530 {
lab=#net5}
N -140 1410 -140 1450 {
lab=VDD}
N -140 1410 550 1410 {
lab=VDD}
N -100 1480 0 1480 {
lab=VB}
N -440 1760 -440 2080 {
lab=P1}
N -440 2080 580 2080 {
lab=P1}
N 50 1770 50 1940 {
lab=P2}
N 50 1940 50 1980 {
lab=P2}
N 50 1980 880 1980 {
lab=P2}
N -180 1480 -140 1480 {
lab=VDD}
N -180 1410 -180 1480 {
lab=VDD}
N -180 1410 -140 1410 {
lab=VDD}
N -440 1730 -380 1730 {
lab=VDD}
N -10 1740 50 1740 {
lab=VDD}
N 1030 1790 1060 1790 {
lab=0}
N 1060 1790 1080 1790 {
lab=0}
N 1030 1410 1030 1760 {
lab=VDD}
N 990 1410 1030 1410 {
lab=VDD}
N 1030 1820 1030 1880 {
lab=#net6}
N 1030 1940 1030 2260 {
lab=0}
N 1080 1790 1080 2250 {
lab=0}
N 1080 2250 1080 2260 {
lab=0}
N 1030 2260 1080 2260 {
lab=0}
N 920 2260 1030 2260 {
lab=0}
N 910 1410 990 1410 {
lab=VDD}
N 440 1690 440 1770 {
lab=VDD}
N 410 1800 440 1800 {
lab=0}
N 410 1800 410 2250 {
lab=0}
N 410 2250 410 2260 {
lab=0}
N 440 1830 440 1880 {
lab=#net7}
N 440 1940 440 2260 {
lab=0}
N -370 -310 -370 -230 {}
N -370 -310 -50 -310 {}
N -50 -310 -50 -230 {}
C {devices/isource.sym} -1950 -150 0 0 {name=I0 value=5u
}
C {devices/lab_pin.sym} -1810 30 0 0 {name=p1 sig_type=std_logic lab=VB4
}
C {devices/lab_pin.sym} -280 -50 0 0 {name=p2 sig_type=std_logic lab=VB4}
C {devices/lab_pin.sym} 760 60 0 0 {name=p3 sig_type=std_logic lab=VB4}
C {devices/lab_pin.sym} -190 -230 0 0 {name=p4 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} -1820 150 1 0 {name=p8 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} -1820 -520 1 0 {name=p9 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 700 -670 1 0 {name=p10 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 750 -580 1 0 {name=p13 sig_type=std_logic lab=VB1}
C {devices/lab_pin.sym} -1550 -310 1 0 {name=p14 sig_type=std_logic lab=VB2}
C {devices/lab_pin.sym} 760 -440 3 0 {name=p15 sig_type=std_logic lab=VB2}
C {devices/lab_pin.sym} -1380 -230 2 0 {name=p16 sig_type=std_logic lab=VB3}
C {devices/lab_pin.sym} 760 -150 1 0 {name=p17 sig_type=std_logic lab=VB3}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} -1450 0 0 1 {name=M13
L=5
W=8
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} -1720 30 0 0 {name=M12
L=12
W=2
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} -1930 30 0 1 {name=M18
L=12
W=2
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} -1680 -310 0 1 {name=M15
L=20
W=10
nf=1
mult=32
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} -1680 -430 0 1 {name=M16
L=2
W=10
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} -1490 -430 0 0 {name=M17
L=2
W=10
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} -1490 -310 0 0 {name=M14
L=20
W=10
nf=1
mult=32
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} -1470 -370 0 0 {name=p18 sig_type=std_logic lab=D17}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} -210 -50 0 0 {name=M1
L=12
W=2
nf=1
mult=160
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} -300 -230 0 0 {name=M2
L=1
W=80
nf=10
mult=20
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} -90 -230 0 1 {name=M11
L=1
W=80
nf=10
mult=20
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 880 -580 0 0 {name=M20
L=16
W=2
nf=1
mult=164
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 620 -580 0 1 {name=M9
L=16
W=2
nf=1
mult=164
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 880 -440 0 0 {name=M7
L=20
W=10
nf=1
mult=32
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 620 -440 0 1 {name=M8
L=20
W=10
nf=1
mult=32
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 880 60 0 0 {name=M3
L=12
W=2
nf=1
mult=82
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 620 60 0 1 {name=M4
L=12
W=2
nf=1
mult=82
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 620 -150 0 1 {name=M5
L=20
W=4
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 880 -150 0 0 {name=M6
L=20
W=4
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} -110 -150 0 0 {name=p20 sig_type=std_logic lab=P}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} -1450 -190 0 1 {name=M10
L=20
W=4
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} -1470 -90 0 1 {name=p11 sig_type=std_logic lab=D13}
C {devices/lab_pin.sym} 410 -510 1 0 {name=p19 sig_type=std_logic lab=A}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 2040 -570 0 0 {name=M19
L=16
W=2
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 1780 -570 0 1 {name=M21
L=16
W=2
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 1930 -330 0 1 {name=M22
L=12
W=4
nf=2
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 2390 -330 0 1 {name=M24
L=12
W=4
nf=2
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 1740 -330 0 0 {name=M25
L=12
W=4
nf=2
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 2080 -40 0 0 {name=p27 sig_type=std_logic lab=VB4}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 2190 -40 0 0 {name=M26
L=12
W=2
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 1930 -40 0 1 {name=M27
L=12
W=2
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 600 -300 0 0 {name=p28 sig_type=std_logic lab=VON}
C {devices/lab_pin.sym} 900 -300 2 0 {name=p29 sig_type=std_logic lab=VOP}
C {devices/lab_pin.sym} 1840 -330 1 0 {name=p30 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 1680 -330 0 0 {name=p31 sig_type=std_logic lab=VON}
C {devices/lab_pin.sym} 2460 -330 0 1 {name=p32 sig_type=std_logic lab=VOP}
C {devices/lab_pin.sym} 2300 -330 1 0 {name=p33 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 2100 -330 1 0 {name=p12 sig_type=std_logic lab=VCM}
C {devices/lab_pin.sym} 2100 30 1 0 {name=p25 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 1960 -640 1 0 {name=p35 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1970 -550 0 0 {name=p21 sig_type=std_logic lab=VB1}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 2190 -330 0 0 {name=M23
L=12
W=4
nf=2
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} -1580 -430 1 0 {name=p36 sig_type=std_logic lab=VB}
C {devices/lab_pin.sym} 600 -60 0 0 {name=p41 sig_type=std_logic lab=P1}
C {devices/lab_pin.sym} 900 -60 0 0 {name=p42 sig_type=std_logic lab=P2}
C {devices/lab_pin.sym} 20 180 1 0 {name=p5 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} -40 -230 1 1 {name=p6 sig_type=std_logic lab=INP}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 90 -340 0 1 {name=M30
L=10
W=60
nf=1
mult=20
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} -440 -350 0 0 {name=M31
L=10
W=60
nf=1
mult=20
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} -100 -600 0 1 {name=M28
L=2
W=10
nf=1
mult=160
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 0 -600 1 0 {name=p7 sig_type=std_logic lab=VB}
C {devices/lab_pin.sym} -360 -350 1 0 {name=p37 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 10 -340 1 0 {name=p38 sig_type=std_logic lab=VDD}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 1030 -290 0 0 {name=M29
L=1
W=50
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/res_generic_l1.sym} 1050 -170 0 0 {name=R1
W=1
L=100000000
model=res_generic_l1
mult=1}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 480 -280 0 1 {name=M32
L=1
W=50
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/res_generic_l1.sym} 460 -170 0 0 {name=R2
W=1
L=100000000
model=res_generic_l1
mult=1}
C {devices/lab_pin.sym} 460 -380 0 0 {name=p39 sig_type=std_logic lab=VDD}
C {devices/code_shown.sym} 2830 -1230 0 0 {name=NGSPICE1
only_toplevel=true
value="* this option enables mos model bin 
* selection based on W/NF instead of W
.option wnflag=1 
.option savecurrents

.control
save all
save @m.xm15.msky130_fd_pr__pfet_g5v0d10v5[vth]
save @m.xm15.msky130_fd_pr__pfet_g5v0d10v5[gm]
save @m.xm9.msky130_fd_pr__pfet_g5v0d10v5[vth]
save @m.xm9.msky130_fd_pr__pfet_g5v0d10v5[gm]
save @m.xm8.msky130_fd_pr__pfet_g5v0d10v5[vth]
save @m.xm8.msky130_fd_pr__pfet_g5v0d10v5[gm]
save @m.xm20.msky130_fd_pr__pfet_g5v0d10v5[vth]
save @m.xm20.msky130_fd_pr__pfet_g5v0d10v5[gm]
save @m.xm7.msky130_fd_pr__pfet_g5v0d10v5[vth]
save @m.xm7.msky130_fd_pr__pfet_g5v0d10v5[gm]
save @m.xm10.msky130_fd_pr__nfet_g5v0d10v5[gm]
save @m.xm10.msky130_fd_pr__nfet_g5v0d10v5[vth]
save @m.xm14.msky130_fd_pr__pfet_g5v0d10v5[gm]
save @m.xm14.msky130_fd_pr__pfet_g5v0d10v5[vth]
save @m.xm16.msky130_fd_pr__pfet_g5v0d10v5[gm]
save @m.xm16.msky130_fd_pr__pfet_g5v0d10v5[vth]
save @m.xm17.msky130_fd_pr__pfet_g5v0d10v5[gm]
save @m.xm17.msky130_fd_pr__pfet_g5v0d10v5[vth]
save @m.xm13.msky130_fd_pr__nfet_g5v0d10v5[gm]
save @m.xm13.msky130_fd_pr__nfet_g5v0d10v5[vth]
save @m.xm12.msky130_fd_pr__nfet_g5v0d10v5[vth]
save @m.xm18.msky130_fd_pr__nfet_g5v0d10v5[vth]
*folded 
save @m.xm2.msky130_fd_pr__nfet_g5v0d10v5[vth]
save @m.xm11.msky130_fd_pr__nfet_g5v0d10v5[vth]
save @m.xm1.msky130_fd_pr__nfet_g5v0d10v5[vth]
save @m.xm5.msky130_fd_pr__nfet_g5v0d10v5[vth]
save @m.xm6.msky130_fd_pr__nfet_g5v0d10v5[vth]
save @m.xm4.msky130_fd_pr__nfet_g5v0d10v5[vth]
save @m.xm3.msky130_fd_pr__nfet_g5v0d10v5[vth]
save @m.xm7.msky130_fd_pr__pfet_g5v0d10v5[vth]
save @m.xm8.msky130_fd_pr__pfet_g5v0d10v5[vth]
save @m.xm9.msky130_fd_pr__pfet_g5v0d10v5[vth]
save @m.xm20.msky130_fd_pr__pfet_g5v0d10v5[vth]
*CMFB
save @m.xm21.msky130_fd_pr__pfet_g5v0d10v5[vth]
save @m.xm19.msky130_fd_pr__pfet_g5v0d10v5[vth]
save @m.xm22.msky130_fd_pr__nfet_g5v0d10v5[vth]
save @m.xm23.msky130_fd_pr__nfet_g5v0d10v5[vth]
save @m.xm25.msky130_fd_pr__nfet_g5v0d10v5[vth]
save @m.xm27.msky130_fd_pr__nfet_g5v0d10v5[vth]
save @m.xm26.msky130_fd_pr__nfet_g5v0d10v5[vth]
save @m.xm24.msky130_fd_pr__nfet_g5v0d10v5[vth]
save current 


write Folded_5u.raw

op
print VON VOP VB2 VB
*print @m.xm18.msky130_fd_pr__nfet_g5v0d10v5
*print @m.xm12.msky130_fd_pr__nfet_g5v0d10v5
*print @m.xm13.msky130_fd_pr__nfet_g5v0d10v5
*print @m.xm10.msky130_fd_pr__nfet_g5v0d10v5
*print @m.xm14.msky130_fd_pr__pfet_g5v0d10v5
*print @m.xm17.msky130_fd_pr__pfet_g5v0d10v5
*print @m.xm15.msky130_fd_pr__pfet_g5v0d10v5
*print @m.xm16.msky130_fd_pr__pfet_g5v0d10v5
*Folded cascode 
*print @m.xm9.msky130_fd_pr__pfet_g5v0d10v5
*print @m.xm8.msky130_fd_pr__pfet_g5v0d10v5
*print @m.xm5.msky130_fd_pr__nfet_g5v0d10v5
*print @m.xm4.msky130_fd_pr__nfet_g5v0d10v5
*print @m.xm1.msky130_fd_pr__nfet_g5v0d10v5
*print @m.xm2.msky130_fd_pr__nfet_g5v0d10v5
*print @m.xm11.msky130_fd_pr__nfet_g5v0d10v5
*CMFB
print @m.xm23.msky130_fd_pr__nfet_g5v0d10v5
print @m.xm24.msky130_fd_pr__nfet_g5v0d10v5
print @m.xm25.msky130_fd_pr__nfet_g5v0d10v5
print @m.xm22.msky130_fd_pr__nfet_g5v0d10v5
*print @m.xm9.msky130_fd_pr__pfet_g5v0d10v5
*print @m.xm8.msky130_fd_pr__pfet_g5v0d10v5
*print @m.xm4.msky130_fd_pr__nfet_g5v0d10v5
*print @m.xm5.msky130_fd_pr__nfet_g5v0d10v5
print @m.xm28.msky130_fd_pr__pfet_g5v0d10v5
*print @m.xm26.msky130_fd_pr__nfet_g5v0d10v5
*print @m.xm27.msky130_fd_pr__nfet_g5v0d10v5
print @m.xm30.msky130_fd_pr__pfet_g5v0d10v5
print @m.xm31.msky130_fd_pr__pfet_g5v0d10v5
write Folded_5u.raw
ac dec 10 1 1e9
  remzerovec
  write Folded_5u.raw
quit 0
.endc
" }
C {sky130_fd_pr/corner.sym} -525 775 0 0 {name=CORNER1 only_toplevel=true corner=tt}
C {devices/vsource.sym} -15 750 0 0 {name=V4 value=5 savecurrent=false}
C {devices/lab_pin.sym} -15 680 0 0 {name=p22 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -45 820 1 0 {name=p26 sig_type=std_logic lab=0}
C {devices/vsource.sym} 55 750 0 0 {name=V1 value=2.5 savecurrent=false}
C {devices/lab_pin.sym} 55 680 0 0 {name=p34 sig_type=std_logic lab=VCM}
C {devices/vsource.sym} 240 750 0 0 {name=V3 value="dc 2.5 ac 1u 180"  net_name=true}
C {devices/lab_pin.sym} 240 690 0 0 {name=p23 sig_type=std_logic lab=INN}
C {devices/vsource.sym} -140 750 0 0 {name=V2 value="dc 2.5 ac 1u 0"  net_name=true}
C {devices/lab_pin.sym} -140 690 0 0 {name=p24 sig_type=std_logic lab=INP}
C {devices/isource.sym} -1970 1930 0 0 {name=I1 value=5u
}
C {devices/lab_pin.sym} -1830 2110 0 0 {name=p40 sig_type=std_logic lab=VB4
}
C {devices/lab_pin.sym} -300 2030 0 0 {name=p44 sig_type=std_logic lab=VB4}
C {devices/lab_pin.sym} 740 2140 0 0 {name=p45 sig_type=std_logic lab=VB4}
C {devices/lab_pin.sym} -210 1850 0 0 {name=p46 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} -1840 2230 1 0 {name=p47 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} -1840 1560 1 0 {name=p48 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 680 1410 1 0 {name=p49 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 730 1500 1 0 {name=p50 sig_type=std_logic lab=VB1}
C {devices/lab_pin.sym} -1570 1770 1 0 {name=p51 sig_type=std_logic lab=VB2}
C {devices/lab_pin.sym} 740 1640 3 0 {name=p52 sig_type=std_logic lab=VB2}
C {devices/lab_pin.sym} -1400 1850 2 0 {name=p53 sig_type=std_logic lab=VB3}
C {devices/lab_pin.sym} 740 1930 1 0 {name=p54 sig_type=std_logic lab=VB3}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} -1470 2080 0 1 {name=M33
L=5
W=8
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} -1740 2110 0 0 {name=M34
L=12
W=2
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} -1950 2110 0 1 {name=M35
L=12
W=2
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} -1700 1770 0 1 {name=M36
L=20
W=10
nf=1
mult=32
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} -1700 1650 0 1 {name=M37
L=2
W=10
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} -1510 1650 0 0 {name=M38
L=2
W=10
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} -1510 1770 0 0 {name=M39
L=20
W=10
nf=1
mult=32
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} -1490 1710 0 0 {name=p55 sig_type=std_logic lab=D17}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} -230 2030 0 0 {name=M40
L=12
W=2
nf=1
mult=160
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} -320 1850 0 0 {name=M41
L=1
W=80
nf=10
mult=20
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} -110 1850 0 1 {name=M42
L=1
W=80
nf=10
mult=20
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 860 1500 0 0 {name=M43
L=16
W=2
nf=1
mult=164
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 600 1500 0 1 {name=M44
L=16
W=2
nf=1
mult=164
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 860 1640 0 0 {name=M45
L=20
W=10
nf=1
mult=32
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 600 1640 0 1 {name=M46
L=20
W=10
nf=1
mult=32
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 860 2140 0 0 {name=M47
L=12
W=2
nf=1
mult=82
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 600 2140 0 1 {name=M48
L=12
W=2
nf=1
mult=82
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 600 1930 0 1 {name=M49
L=20
W=4
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 860 1930 0 0 {name=M50
L=20
W=4
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} -130 1930 0 0 {name=p56 sig_type=std_logic lab=P}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} -1470 1890 0 1 {name=M51
L=20
W=4
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} -1490 1990 0 1 {name=p57 sig_type=std_logic lab=D13}
C {devices/lab_pin.sym} 390 1570 1 0 {name=p58 sig_type=std_logic lab=A}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 2020 1510 0 0 {name=M52
L=16
W=2
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 1760 1510 0 1 {name=M53
L=16
W=2
nf=1
mult=4
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 1910 1750 0 1 {name=M54
L=12
W=4
nf=2
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 2370 1750 0 1 {name=M55
L=12
W=4
nf=2
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 1720 1750 0 0 {name=M56
L=12
W=4
nf=2
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 2060 2040 0 0 {name=p59 sig_type=std_logic lab=VB4}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 2170 2040 0 0 {name=M57
L=12
W=2
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 1910 2040 0 1 {name=M58
L=12
W=2
nf=1
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} 580 1780 0 0 {name=p60 sig_type=std_logic lab=VON}
C {devices/lab_pin.sym} 880 1780 2 0 {name=p61 sig_type=std_logic lab=VOP}
C {devices/lab_pin.sym} 1820 1750 1 0 {name=p62 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 1660 1750 0 0 {name=p63 sig_type=std_logic lab=VON}
C {devices/lab_pin.sym} 2440 1750 0 1 {name=p64 sig_type=std_logic lab=VOP}
C {devices/lab_pin.sym} 2280 1750 1 0 {name=p65 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 2080 1750 1 0 {name=p66 sig_type=std_logic lab=VCM}
C {devices/lab_pin.sym} 2080 2110 1 0 {name=p67 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} 1940 1440 1 0 {name=p68 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 1950 1530 0 0 {name=p69 sig_type=std_logic lab=VB1}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 2170 1750 0 0 {name=M59
L=12
W=4
nf=2
mult=2
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} -1600 1650 1 0 {name=p70 sig_type=std_logic lab=VB}
C {devices/lab_pin.sym} 580 2020 0 0 {name=p71 sig_type=std_logic lab=P1}
C {devices/lab_pin.sym} 880 2020 0 0 {name=p72 sig_type=std_logic lab=P2}
C {devices/lab_pin.sym} -400 1850 1 0 {name=p73 sig_type=std_logic lab=INN}
C {devices/lab_pin.sym} 0 2260 1 0 {name=p74 sig_type=std_logic lab=0}
C {devices/lab_pin.sym} -60 1850 1 1 {name=p75 sig_type=std_logic lab=INP}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} 70 1740 0 1 {name=M60
L=10
W=60
nf=1
mult=20
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} -460 1730 0 0 {name=M61
L=10
W=60
nf=1
mult=20
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/pfet_g5v0d10v5.sym} -120 1480 0 1 {name=M62
L=2
W=10
nf=1
mult=160
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=pfet_g5v0d10v5
spiceprefix=X
}
C {devices/lab_pin.sym} -20 1480 1 0 {name=p76 sig_type=std_logic lab=VB}
C {devices/lab_pin.sym} -380 1730 1 0 {name=p77 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} -10 1740 1 0 {name=p78 sig_type=std_logic lab=VDD}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 1010 1790 0 0 {name=M63
L=1
W=50
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/res_generic_l1.sym} 1030 1910 0 0 {name=R3
W=1
L=100000000
model=res_generic_l1
mult=1}
C {sky130_fd_pr/nfet_g5v0d10v5.sym} 460 1800 0 1 {name=M64
L=1
W=50
nf=1
mult=10
ad="'int((nf+1)/2) * W/nf * 0.29'" 
pd="'2*int((nf+1)/2) * (W/nf + 0.29)'"
as="'int((nf+2)/2) * W/nf * 0.29'" 
ps="'2*int((nf+2)/2) * (W/nf + 0.29)'"
nrd="'0.29 / W'" nrs="'0.29 / W'"
sa=0 sb=0 sd=0
model=nfet_g5v0d10v5
spiceprefix=X
}
C {sky130_fd_pr/res_generic_l1.sym} 440 1910 0 0 {name=R4
W=1
L=100000000
model=res_generic_l1
mult=1}
C {devices/lab_pin.sym} 440 1700 0 0 {name=p79 sig_type=std_logic lab=VDD}
